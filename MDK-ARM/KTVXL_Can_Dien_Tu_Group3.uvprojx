# Keil uVision project KTVXL_Can_Dien_Tu_Group3.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: KTVXL_Can_Dien_Tu_Group3 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\KTVXL_Can_Dien_Tu_Group3\core\inc;.\KTVXL_Can_Dien_Tu_Group3\driver\cmsis;.\KTVXL_Can_Dien_Tu_Group3\driver\inc;.\KTVXL_Can_Dien_Tu_Group3\driver\src;.\KTVXL_Can_Dien_Tu_Group3\driver\cmsis
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User_Core
    ./KTVXL_Can_Dien_Tu_Group3/core/src/: main.c app_scale.c button.c filter.c hx711.c oled.c storage.c uart_cmd.c ui_display.c w25qxx.c
  group CMSIS
    ./KTVXL_Can_Dien_Tu_Group3/driver/cmsis/: core_cm3.c system_stm32f10x.c startup_stm32f10x_md.s
  group StdPeriph_Driver
    ./KTVXL_Can_Dien_Tu_Group3/driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
